# Keil uVision project stepFR.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stepFR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\stepFR;.\board;.\addLib;.\rtos\include;.\rtos\portable\Common;.\rtos\portable\RVDS\ARM_CM3;.\rtos\Trace\Include;.\rtos\Trace\streamports\File\include;.\rtos\Trace\config;.\board\L6470
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
  group source
    ./board/: board.c clk.c Led.c MDR32F9Qx_it.c Reset.c serial.c uartTimer.c spi.c spiRtos.c l6470Timer.c Input.c CalcDrive2.c
    ./board/L6470/: L6470.c
  group header
    ./board/: board.h clk.h Led.h MDR32F9Qx_it.h Reset.h serial.h uartTimer.h spi.h spiRtos.h l6470Timer.h Input.h CalcDrive2.h
    ./: FreeRTOSConfig.h
    ./board/L6470/: L6470.h
  group rtos_h
    ./rtos/include/: FreeRTOS.h list.h queue.h task.h timers.h semphr.h croutine.h
  group rtos_c
    ./rtos/: list.c queue.c tasks.c timers.c
    ./rtos/portable/RVDS/ARM_CM3/: port.c
    ./rtos/portable/MemMang/: heap_2.c
  group trace
    ./rtos/Trace/: trcKernelPort.c trcStreamingRecorder.c trcSnapshotRecorder.c
    ./rtos/Trace/config/: trcConfig.h trcSnapshotConfig.h trcStreamingConfig.h
software components: Device:Startup 2.0.3, Drivers:DMA 2.0.3, Drivers:IWDG 2.0.3, Drivers:PORT 2.0.3, Drivers:RST_CLK 2.0.3, Drivers:SSP 2.0.3, Drivers:TIMER 2.0.3, Drivers:UART 2.0.3
